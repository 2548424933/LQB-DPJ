# Keil uVision project ba.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ba +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Device;.\System
  group Main
    ./: STARTUP.A51 main.c
  group Device
    ./Device/: Device.c KBD.c SMG.c ds1302.c onewire.c BTN.c
  group System
    ./System/: System.c
