# Keil uVision project Si.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Si +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Device;.\System;.\Listings;.\Objects
  group main
    ./: STARTUP.A51 main.c
  group System
    ./System/: System.c timer.c
  group Device
    ./Device/: BTM.c SMG.c Device.c ADPCF.c
    ./: KBD.c
    ../蜂鸣器/Device/: iic.c
