# Keil uVision project liu.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: liu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Device;.\System
  group Main
    ./: STARTUP.A51 main.c
  group Device
    ./Device/: device.c KBD.c SMG.c onewire.c ds1302.c
  group System
    ./System/: System.c
