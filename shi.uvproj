# Keil uVision project shi.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: shi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Device;.\System
  group Main
    ./: main.c STARTUP.A51
  group Device
    ./Device/: device.c KBD.c SMG.c iic.c
  group System
    ./System/: System.c
