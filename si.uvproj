# Keil uVision project si.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 第四届智能灌溉 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\System;.\Device
  group Main
    ./: STARTUP.A51 main.c
  group System
    ./System/: System.c Timer.c Delay.c
  group Device
    ./Device/: SMG.c Device.c ds1302.c iic.c BTN.c
